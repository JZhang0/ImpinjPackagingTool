# IAR project sam4l_sam-ba_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __ATSAM4LC4C__; BOARD=SAM4L_EK; UDD_ENABLE; UDD_NO_SLEEP_MGR; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\utils\cmsis\sam4l\include; ..\..\..\..\..\common\services\usb\class\cdc; ..\..\..\..\utils\header_files; ..\..\..\..\drivers\flashcalw; ..\..\..\..\utils\cmsis\sam4l\source\templates; ..\..; ..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\drivers\bpm; ..\..\..\..\drivers\usbc; ..\..\..\..\utils; ..\..\..\..\..\common\services\usb; ..\..\..\..\drivers\gpio; ..\..\..\..\..\common\services\clock; ..\..\..\..\..\common\boards; ..\..\..\..\..\common\utils; ..; ..\..\..\..\..\common\services\usb\udc; ..\..\..\..\boards\sam4l_ek; ..\..\..\..\utils\preprocessor; ..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\boards; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: sam4l_sam-ba_flash.hex
  ILINK.IlinkOutputFile: sam4l_sam-ba_flash.out
  ILINK.IlinkIcfFile: ..\..\sam-ba_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  OBJCOPY.OOCOutputFile: sam4l_sam-ba_flash.bin
  group common/services/clock/sam4l
    ../../../../../common/services/clock/sam4l/: dfll.c osc.c pll.c sysclk.c
  group common/services/sleepmgr/sam4l
    ../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c
  group common/services/usb/class/cdc/device
    ../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group sam/applications/sam4l_sam-ba
    ../../: main.c sam_ba_monitor.c usart_sam_ba.c
  group sam/boards/sam4l_ek
    ../../../../boards/sam4l_ek/: init.c
  group sam/drivers/bpm
    ../../../../drivers/bpm/: bpm.c
  group sam/drivers/flashcalw
    ../../../../drivers/flashcalw/: flashcalw.c
  group sam/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group sam/drivers/usbc
    ../../../../drivers/usbc/: usbc_device.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../utils/cmsis/sam4l/source/templates/: exceptions.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
